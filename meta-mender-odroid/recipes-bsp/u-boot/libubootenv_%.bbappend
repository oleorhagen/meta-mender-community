

do_install_prepend() {
    install -d ${D}${sysconfdir}
}